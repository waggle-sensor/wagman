# EAGLE board WagmanV3-1-2016-02-02-32 (EAGLE 7.2.0), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
1V8  (via drill 0.36 pad 0.71)
  Top 0.254: Q9.1 R50.1
  Top 0.305: R50.1 59.67,18.8 v59.09,18.23 | v59.09,7.8 59.09,2.97 v59.12,3
  Top 0.406: D1.3 58.1,22.5 60.05,20.55 Q9.1
  Top 0.61: J7.6 38,2.15
  Top 0.813: 93.65,4.65 v93.7,4.7 | v71.5,4.8 71.55,4.75 | 15.9,2.15 J8.6 | 95.02,44.1 U31.2
  Top 1.27: J5.6 93.65,4.65 | 71.55,4.75 J6.6 | v15.9,4.8 15.9,2.15 | v97.86,30.43 96.51,30.43 95.5,29.42 95.5,22.35 v93.7,20.55 | 38,2.15 v38,4.4 | C2.1 95.02,44.1 | U31.2 95.06,43.72 v97.86,40.92
  Bottom 0.305: v59.09,18.23 v59.09,7.8
  Bottom 1.27: v93.7,20.55 v93.7,4.7 93.7,4.1 91.8,2.2 71.8,2.2 | v97.86,40.92 v97.86,30.43 | v15.9,4.8 18.5,2.2 38.5,2.2 | 38.5,2.2 59.12,2.2 | 59.12,2.2 71.8,2.2 | v71.5,4.8 71.8,4.5 71.8,2.2 | v59.12,3 59.12,2.2 | v38,4.4 38.5,3.9 38.5,2.2
1V8D7  (via drill 0.36 pad 0.71)
  Top 0.254: Q9.2 61.95,19.3 R50.2
  Top 0.305: R50.2 v62.92,19.1 | v60.83,12.8 R39.2
  Bottom 0.305: v62.92,19.1 62.92,14.89 v60.83,12.8
3V3  (via drill 0.36 pad 0.71, 0.6)
  Top 0.254: 32.53,79.22 Q2.1 | 35.99,79.65 Q1.1 | R22.1 v37.25,81.55 | Q8.1 33.8,44.55 R9.1 32.35,44.65 26,38.3 26,26.9 26.7,26.2 26.7,22.8 26.36,22.46 U16.6 U16.9 U16.10 27.63,15.04 v27.02,14.4 | 10.34,75.44 10.34,75.26 10.4,75.2 | C8.1 C4.1 34.8,14.73 34.48,14.4 v34,14.4 | 32.43,80.2 arc-90 32.53,80.1 | v124.78,54.68 123.93,53.83 114.75,53.83 114.27,54.32 C18.1 | R12.1 R11.1 | v125.9,59.1 125.92,59.08 C20.1 | U5.8 103.55,59.05 103.43,58.93 C21.1 102.03,58.93 101.6,58.5 v101.6,54.13 101.47,54.01 94.05,54.01 93.44,53.4 89.9,53.4 | 80.35,59.03 78.03,59.03 77.6,58.6 77.6,55.6 77.97,55.23 C19.1 77.97,53.87 | 77.97,53.87 76.63,52.53 R12.1 | R12.1 72.78,52.6 v71.7,52.6 | v68.6,52.6 66.8,52.6 v64.8,54.6 | U6.8 90.42,59.05 88.9,57.53 88.9,55.3 89.38,54.82 C22.1 89.9,54.8 89.9,53.4 | 89.9,53.4 86.6,53.4 | 86.6,53.4 81,53.4 80.53,53.87 77.97,53.87 | R19.1 86.6,54.27 86.6,53.4
  Top 0.305: U7.8 114.55,59.05 114.25,58.75 R3.1 114.25,54.77 C18.1 114.27,54.45 113.92,54.1 101.63,54.1 v101.6,54.13
  Top 0.406: R22.1 35.99,79.65 | R26.1 32.53,82.23 32.92,82.62 35.63,82.62 36,82.25 R22.1 | U4.8 126.86,59.05 C20.1 126.81,59.1 | U9.8 68.66,59.03 C23.1 64.83,59.03 v64.8,59 v64.8,54.6 | U8.8 80.35,59.03 | v41.65,52.8 38.3,52.8 33.8,48.3 R9.1 | C16.1 7.55,75.65 8,75.2 10.4,75.2 24.6,75.2 v24.7,75.1 | U11.5 10.34,75.44 | 32.4,81.32 R26.1 | 32.53,79.22 32.53,80.1 R26.1 | v31.9,80.2 32.43,80.2 | v99.75,43.99 D4.C
  Top 0.813: U31.3 C3.1 100.45,45 D4.C
  Top 1.778: U30.3 PC3.+ | PC3.+ | PC3.+ 121.6,49.21 v121.67,49.28
  Bottom 0.254: v27.02,14.4 v34,14.4 | v124.78,54.68 125.9,55.8 v125.9,59.1 | v71.7,52.6 v68.6,52.6
  Bottom 0.305: v64.8,59 64.8,61.5 44.75,81.55 v37.25,81.55 | v124.78,54.68 v124.78,54.67 121.67,51.56 v121.67,49.28
  Bottom 0.406: v41.65,52.8 64.1,52.8 64.8,53.5 v64.8,54.6 | v24.7,75.1 29.8,80.2 v31.9,80.2 | v101.6,54.13 101.6,50.93 99.75,49.1 v99.75,43.99
3V3D5*  (via drill 0.36 pad 0.71)
  Top 0.254: Q8.2 34.75,42.65 34.5,42.9 33.85,42.9 R9.2
  Top 0.305: R47.2 56.3,16.1 53.6,18.8 43.86,18.8 39.39,23.27 v38.5,24.2
  Top 0.406: v27,27.5 27,38.1 31.85,42.95 R9.2
  Bottom 0.254: v27,27.5 37.6,27.5 38.1,27 38.1,24.6 v38.5,24.2
+5V  (via drill 0.36 pad 0.71)  (1 unrouted)
  Top 0.254: 44.3,56.58 L2.1 | R23.1 R25.2 36.96,73.3 | 44.2,56.68 L2.1 | R29.2 42.64,46.64 42.3,46.3 U10.5 | C10.1 30.83,28.59 R1.1 30.9,28.61 30.9,29.2 31.3,29.6 33.9,29.6 34.51,30.21 J2.2 34.51,30.91 | C10.1 C11.1 | v55.7,84.1 55.8,84.2 JP11.1 | U1.2 41.54,60.96 v44.38,58.12 L2.1 | C10.1 v30,29.3 | R23.1 38.77,75.24 42,72.01 v42,69.8 39.19,66.99 U1.14 | U1.34 34.16,59.69 v34,59.65 v34,57.1 | U1.24 32.53,64.96 v32.19,65.17 | R23.1 v36.89,76.39 v36.9,76.4 | 123.69,61.59 v123.6,61.5 | 123.65,60.95 123.6,60.9 v123.6,60.6
  Top 0.305: JP11.1 57.6,81.5 59.56,79.54 71.52,79.54 R20.2 | U29.3 43.73,92.57 44,92.3 C17.1 47.27,91.75 49.51,89.51 v49.51,84.1 43.58,78.17 v37.33,78.17 34.5,78.17 34,77.67 34,75.8 33.44,75.24 R28.1 R24.2 | L2.1 44.38,47.98 43.7,47.3 R29.2 | R5.1 126.2,86.28 v126.2,81.7
  Top 0.406: C24.1 v76.83,80.2 U2.8 74.47,81.17 73.9,80.6 72.58,80.6 R20.2 | 42.74,47.2 R29.2 | R30.1 37.9,46.4 38.9,45.4 38.9,39 v37.2,37.3 | 123.9,60 123.58,59.68 U7.18 123.72,59.68 | U7.24 | 123.72,60.32 123.9,60.5 | U7.20 123.65,60.95 123.9,61.2 | 123.69,61.59 123.9,61.8 | 123.72,62.22 v123.6,62.4 | 123.74,62.86 123.9,62.7 | 77.84,33.1 D11.C | v96,33.1 95.95,33.05 | 51.9,26.55 K5.2
  Top 0.61: R29.2 42.6,47.34 42.6,48.5 42,49.1 37.6,49.1 36.55,48.05 R30.1 | v37.2,37.3 32.78,37.3 D2.C | v46.9,56.5 L2.1 | 128.99,33 D10.C | v61.4,56.5 61.4,53.4 65.8,49 65.8,41.9 70.15,37.55 v95.1,37.55 95.42,37.23 104.01,37.23
  Top 0.813: 115.75,4.85 v115.8,4.9
  Top 1.016: 123.9,60 123.9,60.5 123.9,61.2 123.9,61.8 123.9,62 v123.6,62.4 123.9,62.7 123.9,63.2 123.85,63.25 | 123.85,63.25 123.6,63.5 U7.24 | U7.19 123.72,60.32 | U7.21 123.69,61.59 | U7.22 123.72,62.22 | U7.23 123.74,62.86 | v123.57,63.3 123.85,63.25
  Top 1.27: J9.6 115.75,4.85 | v66.7,22.8 63.95,25.55 R52.1 59.75,25.55 58.2,24 53,24 51.9,25.1 51.9,26.55 | v79.5,33.1 77.84,33.1 | K1.2 132.77,29.23 131.42,30.59 128.99,33 | 95.95,33.05 D8.C | K5.2 51.86,31.47 D12.C
  Top 1.778: U30.1 111.99,39.84 D6.C 111.95,39.31 D9.C 104.01,37.23 104.01,43.05 105.16,44.2 PC1.+
  Bottom 0.254: v49.51,84.1 v55.7,84.1 | v30,29.3 8.92,29.3 R10.1 | v42,69.8 46.6,65.2 46.6,60.34 v44.38,58.12 43.36,57.1 v34,57.1 | 34.03,59.73 v34,59.65 34.04,59.69 34.04,61.85 32.19,63.69 v32.19,65.17 | v36.9,76.4 36.9,77.75 v37.33,78.17
  Bottom 0.305: v126.2,81.7 124.7,80.2 v76.83,80.2
  Bottom 0.406: v111.46,42.77 112.47,42.77 | 112.47,42.77 v112.5,42.8 | v111.43,41.85 112.02,41.85 | 112.47,42.77 112.47,41.85 | 112.47,41.85 v112.5,41.83 | 112.47,41.85 112.02,41.85 | 112.02,41.85 112.01,41.86
  Bottom 0.61: v37.2,37.3 37.2,34 35.06,31.86 J2.2 | v46.9,56.5 v61.4,56.5 | v95.1,37.55 96,36.65 v96,33.1
  Bottom 1.016: K4.2 81.5,26.62 | 132.8,26.56 K1.2 | 115.67,22.28 115.6,22.21
  Bottom 1.27: 81.33,22.21 67.42,22.21 v66.7,22.8 | 81.33,22.21 98.03,22.21 | 98.03,22.21 108.9,22.21 | 108.9,22.21 115.6,22.21 | K2.2 115.67,22.28 131.48,22.28 132.8,23.6 132.8,26.56 | 81.33,22.21 81.5,22.25 81.5,26.62 81.5,31.1 v79.5,33.1 | 98.03,22.21 98.57,22.37 K3.2 96,29.16 v96,33.1 | 108.9,22.21 109.6,22.14 109.6,11.1 v115.8,4.9
  Bottom 1.778: v123.57,63.3 124.35,62.4 124.35,56.5 121.18,53.33 115.26,53.33 112.01,50.09 112.01,41.86 111.99,41.83 | 111.99,41.83 111.99,42.65 | 111.99,41.2 111.99,41.83
A0  (via drill 0.36 pad 0.71)
  Top 0.254: U1.36 36.19,58.19 v21.4,43.4 | R13.P$5 25.42,39.38 v25.4,39.4
  Top 0.305: J9.5 118.25,4.83 105.62,17.46 67.77,17.46 65.4,15.1 55.9,15.1 53.3,17.7 43.84,17.7 43.51,17.77 v39.59,21.7
  Bottom 0.254: v25.4,39.4 v21.4,43.4
  Bottom 0.305: R13.P$5 25.42,23.88 26.33,22.97 38.32,22.97 v39.59,21.7
A1  (via drill 0.36 pad 0.71)
  Top 0.254: U1.37 36.69,57.69 12.63,33.63 R10.2 | R13.P$4 22.88,33.17 v22.45,33.6
  Bottom 0.254: R10.2 22.42,33.63 v22.45,33.6
A2  (via drill 0.36 pad 0.71)
  Top 0.254: U1.38 37.19,56.99 v36.3,56.1 | U29.2 40.5,91.3 40.2,91 40.2,80.3 v40.64,79.86
  Bottom 0.254: v36.3,56.1 43.7,56.1 47.2,59.6 47.2,73.3 v40.64,79.86
A3
  Top 0.254: U1.39 37.69,56.29 19.05,37.65 19.05,23.95 21.5,21.5 R32.2
A4  (via drill 0.36 pad 0.71)
  Top 0.254: U1.40 38.19,55.89 21.6,39.3 21.6,23.85 23.1,22.35 v23.1,15.3
  Top 0.305: R41.2 47.42,9.6 45.52,11.5 v45.54,11.5
  Bottom 0.254: v45.54,11.5 44.54,10.5 32,10.5 31.2,11.3 23.9,11.3 23.1,12.1 23.1,15.2
  Bottom 0.305: 23.1,15.2 v23.1,15.3
A5
  Top 0.254: U1.41 38.69,55.59 26.2,43.1 25.1,42 24.15,41.05 24.15,12.95 R45.2
ADD_V5  (via drill 0.36 pad 0.71)
  Top 0.254: U9.17 72.36,59.05 71.65,58.35 71.65,54.35 70.6,53.3 70.6,50.7 71.99,49.31 R11.2 76.9,49.31 R27.1 | U5.17 108.45,59.05 108,58.6 108,57.63 v107.49,57.12 | U6.17 98.85,59.05 99,58.9 | 99,58.9 99,58.5 98.91,58.41 U6.16 | 99,58.9 99.1,58.8 99.1,55.8 98.9,55.6 v98.17,55.6 | v107.49,53.19 108,53.2
  Top 0.305: U6.17 | U5.17 110.21,59.03 | U4.16 134.31,58.4 | 133.05,58.4 132.78,58.13 132.78,55.4 132.08,54.7 126.1,54.7 124.6,53.2 108,53.2 v95.72,53.2 93.78,51.26 R27.1
  Top 0.35: 134.31,58.4 133.05,58.4
  Top 0.406: U6.17 97.52,59.03
  Bottom 0.254: v107.49,57.12 v107.49,53.19 | v98.17,55.6 95.77,53.2 v95.72,53.2
AREF
  Top 0.254: U1.42 39.2,58.44 39.42,58.22 C6.1
AVCC
  Top 0.254: U1.44 40.27,59.5 41,59.5 42.03,58.47 C7.1 42.03,56.65 L2.2
BAT
  Top 0.813: D3.A 92.42,90.28 94.9,87.8 94.9,83.4 94.8,83.3
  Top 1.016: B2.POS1 117.68,80.38 115.3,78 97.2,78 94.8,80.4 94.8,83.3 94.8,84.28 B2.POS2
D0/RX  (via drill 0.36 pad 0.71)
  Top 0.254: U10.1 41.65,43.35 41,42.7 41,42.15 C1.1 40.9,42.05 40.9,41 41.4,40.5 43.99,40.5 50.22,47.11 50.22,59.48 46.2,63.5 v44.95,63.5 | U1.20 36.18,66.99 32.37,70.8 v31.6,70.8
  Bottom 0.254: v31.6,70.8 31.69,70.8 31.75,70.74 36.2,70.74 40.13,66.8 42.8,66.8 44.96,64.64 44.96,63.75 v44.95,63.5 v44.96,63.5 v44.95,63.5
D1/TX  (via drill 0.36 pad 0.71)
  Top 0.254: U1.21 35.68,66.71 32.67,69.67 32.34,70 26.9,70 v23.7,73.2
  Top 0.305: R31.2 v23.7,80.6
  Bottom 0.305: v23.7,73.2 22.7,74.2 22.7,79.6 v23.7,80.6
D2/SDA  (via drill 0.36 pad 0.71)
  Top 0.254: U1.19 36.69,67.35 31.7,72.34 31.7,73.22 | 31.7,73.22 R24.1 | 31.7,73.22 R28.2 | R28.2 31.69,77.01 Q2.3 | U2.5 74.44,84.97 v74.39,84.89 | 31.63,75.3 R28.2 | v65.2,82.15 65.2,84.18 JP11.4 65.22,82.3 v65.2,82.15
  Top 0.305: v30.7,76.4 31.4,77.1 Q2.3
  Bottom 0.305: v74.39,84.89 67.94,84.89 v65.2,82.15 61.45,85.9 35.9,85.9 33.8,83.8 33.8,79 33.3,78.5 31.3,78.5 30.7,77.9 v30.7,76.4
D3/SCL
  Top 0.254: U1.18 37.19,67.57 34,70.76 34,71.5 35.2,72.7 35.2,73.22 R25.1 R23.2 35.19,77.2 Q1.3
  Top 0.305: U2.6 71.17,83.7 70.48,83.01 70.48,81.15 69.66,80.33 60.71,80.33 60.14,80.9 JP11.2 60.2,84.26 60.2,85.72 59.62,86.3 53.1,86.3 44.1,77.3 Q1.3
D4*  (via drill 0.36 pad 0.71)
  Top 0.254: U1.25 27.36,64.46 26.5,63.6 v26.5,56.1 | v45.68,44.28 45,43.6 U10.3 | R46.2 57.2,17.4 v56.55,18.05
  Bottom 0.254: v26.5,56.1 26.5,54.5 29.49,51.51 29.49,49.45 34.33,44.61 45.35,44.61 v45.68,44.28 56.55,33.28 v56.55,18.05
D5*  (via drill 0.36 pad 0.71)
  Top 0.254: U1.31 31.66,61.46 31.2,61 31.2,55.03 v31.4,54.83 | v34.8,48 34.8,46.45 R30.2 34.9,46.35 34.9,45.7 35.3,45.3 37.5,45.3 37.8,45 Q8.3
  Bottom 0.254: 34.8,51 34.8,51.43 v31.4,54.83
  Bottom 0.305: v34.8,48 34.8,51
D6*  (via drill 0.36 pad 0.71)
  Top 0.254: U1.27 29.56,63.46 28.3,62.2 v28.3,56.8 | R15.2 57.39,40.8 v56.2,40.8
  Top 0.305: R38.2 v60.85,14.2
  Bottom 0.254: v56.2,40.8 51.9,40.8 45.8,46.9 42.7,46.9 32.4,57.2 28.7,57.2 v28.3,56.8 28.5,57
  Bottom 0.305: v60.85,14.2 60.85,36.15 v56.2,40.8
D7  (via drill 0.36 pad 0.71, 0.6)
  Top 0.254: U1.1 41.24,60.46 43.3,58.4 v43.3,50.93 | Q9.3 R52.2 62.25,23.85 v62.3,23.9
  Bottom 0.254: v62.3,23.9 62.3,36.4 56.7,42 53.5,42 v46.83,48.67 44.57,50.93 v43.3,50.93
D_N
  Top 0.254: RN1.7 16.08,59.5 Z2.1 16,59.58 J3.2
D_P
  Top 0.254: RN1.8 18.51,58.7 Z1.1 15.08,58.52 14.67,58.93 J3.3
FAULT_PU  (via drill 0.36 pad 0.71)
  Top 0.254: U8.15 83.62,57.78 83.3,58.1 83.3,64.2 v83.8,64.95 | U6.15 95.92,57.78 95.6,58.1 95.6,64.5 v96.18,64.95 | U7.15 123.58,57.78 124.9,59.1 124.9,64.6 v125,64.95 | v113.73,64.95 113.8,64.5 113.8,59.2 112.38,57.78 U5.15 | U4.15 136.04,57.78 v136.32,58.05
  Top 0.305: 112.38,57.78 112.48,57.78 R3.2
  Top 0.406: U9.15 75.18,57.78 v75.68,57.8
  Bottom 0.254: v136.32,58.05 136.3,58.04 132.72,58.04 131.57,59.18 131.57,63.25 129.86,64.95 v125,64.95 v113.73,64.95 v96.18,64.95 v83.8,64.95 73.6,64.95 73.1,64.2 73.1,58.35 U9.15 75.66,57.78 v75.68,57.8
GND  (via drill 0.36 pad 0.71, 0.6)  (22 unrouted)
  Top 0.254: 39.59,62.46 U1.5 42.31,62.46 43.06,61.72 C5.2 | 39.59,62.46 39.09,62.96 38.9,62.96 | 38.9,62.96 U1.EXP | 39.59,62.46 39.69,62.36 U1.43 39.7,59.67 39.7,58.8 40.3,58.2 C6.2 | 38.9,62.96 38.69,63.17 U1.15 38.69,67.29 41.1,69.7 41.1,70.48 41.1,71.9 40.2,72.8 39.5,72.8 C12.1 38.52,71.82 Y3.2 | U1.23 35.19,65.46 35.9,64.75 | 35.9,64.75 U1.EXP | U1.35 35.69,60.96 U1.EXP | C1.2 42.7,42.15 42.7,42.7 42.3,43.1 U10.2 42.29,44.32 42.67,44.7 43.69,44.7 44.2,45.21 45.85,45.21 47.12,46.48 v47.62,46.48 | C11.2 C10.2 | C10.2 29.03,28.67 | C10.2 29.11,31.54 J2.6 | U4.11 130.76,57.14 131.1,56.8 131.1,56 v131,55.9 | 126.82,58.12 C20.2 126.7,58.2 v126.7,55.9 v119.5,55.9 | U7.14 120.04,57.14 119.55,56.65 | 119.55,56.65 119.5,56.6 v119.5,55.9 | U7.16 120.11,58.41 119.5,57.8 119.5,56.7 119.55,56.65 | U7.17 119.95,59.05 119.4,58.5 119.4,57.3 119.4,56 v119.5,55.9 | U5.16 110.22,58.4 | U5.11 105.19,57.1 103.52,57.1 102.97,56.55 v103,56 | U9.11 69.86,57.14 | 70.08,57.14 70.4,56.82 70.4,55.2 69,53.8 v68.3,53.8 | 40.2,57.83 C6.2 | C7.2 41.12,57.82 C6.2 | Q5.2 60.89,34.4 61.83,34.4 | 35.9,64.75 v37.68,62.98 | Z1.2 17.33,57.52 Z2.2 arc90 15.95,57.63 J3.5 J3.4 | JP11.3 62.68,81.92 v62.7,82.15 | C13.1 37.11,72.37 Y3.2 | Y3.4 Y3.2 | U6.11 91.04,57.14 90.65,56.75 90.65,55.95 v90.5,56 90.76,55.8 C22.2 | U6.14 96.04,57.14 95.6,56.7 v95.6,55.9 | U8.14 U8.11 78.74,57.14 78.4,56.8 78.4,55.9 78.86,55.45 C19.2 | U8.17 88.25,59.05 89.1,59.9 89.1,63.83 v88.9,64.15
  Top 0.305: 126.8,58.12 126.7,58.12 | 126.82,58.12 126.8,58.12 | 126.8,58.12 126.8,58.1 | v131,55.9 v126.7,55.9 | v119.5,55.9 115.5,55.9 115.15,55.55 C18.2 | 110.22,58.4 108.71,58.4 108.6,58.29 108.6,56.12 109.12,55.6 v110.1,55.6
  Top 0.406: U2.4 C25.2 | C16.2 7.55,79.45 7.8,79.7 10.3,79.7 | U11.2 10.34,79.66 10.3,79.7 | 10.3,79.7 15.2,79.7 16.2,80.7 J1.2 15.44,83.26 3.35,83.26 2.21,82.12 2.21,72.49 3.58,71.12 | v136.44,55.9 136.34,57.14 U4.14 | U4.17 137.25,59.05 137.6,58.7 137.6,57.06 v136.44,55.9 | U7.11 119.24,57.14 119.4,57.3 | C23.2 66.14,58.15 65.8,57.8 65.8,55.1 67.1,53.8 v68.3,53.8 | 69.86,57.14 70.08,57.14 | v43.8,42.6 43.3,42.1 C1.2 | 61.82,39 61.82,39.38 61.83,39.39 61.83,43.55 60.8,44.58 60.8,46.17 Q3.2 60.83,46.1 v59.9,46.1 | 61.82,39 61.82,37.03 61.83,37.03 61.83,34.4 61.83,29.08 Q6.2 | 61.82,39 Q4.2 56.51,38.99 v56.41,38.96 55.5,38.09 v55.5,32.89 | Q7.2 46.9,34.68 v47.59,35.37 | RX.C TX.C ON.C L1.C L.C 120.37,91.65 | J6.4 76.55,5.24 v75.69,6.1 | J8.4 20.85,7.13 v21.08,7.37 | J7.4 42.95,4.93 v42.97,4.95 42.97,7.57 v42.8,7.75 | R13.P$1 15.26,23.6 17.65,21.21 19.33,21.21 U3.2 17.71,21.14 16.76,20.19 16.76,13.59 17.65,12.7 20.83,12.7 21.34,13.21 v21.34,16.51 21.21,16.64 U12.2 | U16.4 U16.5 27.63,18.34 v27.69,18.29 | U16.14 32.64,15.71 v32.64,17.27 34.63,17.27 C4.2 C8.2 36.3,18.31 v35.81,18.8 | U16.2 31.44,18.87 v31.24,18.67 | U16.12 30.17,13.03 v29.59,12.45 | D1.1 55,20.4 v54.9,20.3 | J9.4 120.75,4.47 v120.65,4.57 | J5.4 98.65,4.73 v98.55,4.83 | v95.63,14.48 v91.19,14.48 | C7.2 41.15,54.74 41.78,54.1 42.16,54.1 42.67,53.59 42.67,52.07 42.04,51.44 42.04,50.29 v43.43,49.53 | C5.2 44.71,61.72 v48.01,58.42 | v31.91,68.52 31.91,68.68 31.24,69.34 19.43,69.34 19.3,69.47 19.3,70.28 R2.1 C9.2 19.32,70.34 19.3,70.36 19.3,71.12 18.8,71.63 16.51,71.63 16,71.12 3.58,71.12 | v41.15,70.57 41.15,70.53 41.1,70.48
  Top 0.406: PC2.- 131.98,70.86 v131.96,70.83 | v130.69,70.83 131.44,70.83 | 131.44,70.83 v131.96,70.83 | v133.22,70.83 132.72,70.83 | 132.72,70.83 v131.96,70.83 | v131.32,69.56 131.32,70.7 131.44,70.83 | 132.72,70.83 132.59,70.7 v132.59,69.56 132.59,66.8 133.35,66.04 133.35,64.77 132.72,64.14 132.72,59.05 133.99,59.05 | v141.48,14.95 v141.48,16.22 | v140.21,16.22 v141.48,16.22 | v142.75,16.22 v141.48,16.22 | v141.48,16.22 v141.48,17.49 143.22,17.49 144.15,18.41 144.15,26.89 v144.02,27.01 v144.02,28.28 v144.02,29.55 v144.02,30.82 | v144.02,30.82 v144.02,32.09 v144.02,33.36 v144.02,34.63 v144.02,35.9 v144.02,37.17 v144.02,38.44 v144.02,39.71 v144.02,40.98 v144.02,42.25 v144.02,43.52 v144.02,44.79 v144.02,46.06 | v144.02,46.06 144.02,46.23 144.15,46.35 144.15,47.21 v144.02,47.33 | v144.02,46.06 142.66,46.06 142.37,46.35 | v136.44,55.9 136.44,55.16 133.35,52.07 128.91,52.07 | 128.91,52.07 115.77,52.07 U30.4 | 128.91,52.07 125.73,48.9 125.73,38.73 133.35,31.11 143.73,31.11 v144.02,30.82 | C21.2 102.72,56.28 v103,56 | U5.14 111.59,57.14 112.04,56.69 112.04,56.06 111.58,55.6 v110.1,55.6 | 120.37,91.65 107.22,91.65 106.15,90.58 106.15,90.47 | B2.NEG 106.15,84.4 106.15,90.47 | R4.2 121.03,87.76 120.34,88.44 120.34,91.62 120.37,91.65 | 106.15,90.47 103.76,92.86 79.43,92.86 78.72,92.15 78.72,78.31 C24.2 | U9.14 74.94,57.14 75.44,56.9 75.69,56.9 75.95,56.64 75.95,56.06 v76.01,56 | C14.- 18.26,65.12 17.14,64.01 3.3,64.01 | 3.3,64.01 3.17,64.01 1.02,61.85 1.02,57.53 1.52,57.02 3.17,57.02 3.56,57.4 3.56,57.66 4.19,58.29 7.08,58.29 7.11,57.78 | 7.11,57.78 7.11,57.91 | 7.11,57.91 3.94,57.91 3.94,58.04
  Top 0.406: 3.94,58.17 3.94,58.04 | 3.94,58.04 7.11,58.04 7.11,57.91 | 7.11,57.78 7.11,57.63 J3.5 | 3.58,71.12 3.58,64.29 3.3,64.01
  Top 0.61: U2.4 82.03,87.67 82,87.7 86.7,87.7 87.3,87.1 87.3,85.93 C27.2 90.4,85.9 91,85.3 91,83.44 Y2.P$3 Y2.P$2 90.9,80.14 90.9,78.12 90.35,77.57 87.39,77.57 C26.2 87.33,76.46 86.74,75.87 79.55,75.87 78.87,76.56 | 78.87,76.56 78.77,76.66 78.77,78.25 C24.2 | v55.88,68.33 58.98,68.33 v60.76,70.1 | v77.81,76.04 78.35,76.04 78.87,76.56 | C17.2 43.17,90.03 U29.1 41.9,88.15 v41.91,84.63 | C19.2 82.98,54.72 v83,54.7 | v83,52.49 v82.96,52.53 82.94,52.55 80.49,52.55 80.08,52.96 R27.2
  Top 0.813: C2.2 95.02,45.9 U31.1 95.06,46.04 95.89,46.86 98.84,46.86 C3.2 100.45,46.8 D4.A 108.27,47.05 109.47,45.85
  Top 1.778: 114.3,47.88 U30.2 114.3,42.8 116.2,40.89 116.2,39.84 D6.A 121.2,39.8 PC3.- | 114.3,47.88 111.51,47.88 109.47,45.85 109.47,41.91 106.81,39.31 PC1.- | U30.4 114.3,47.88
  Top 3.81: PC4.- 141.42,47.3 142.37,46.35 142.37,42.67 140.72,41.15 135.23,41.15 POW.3
  Bottom 0.254: v43.43,49.53 44.58,49.53 v47.62,46.48
  Bottom 0.406: v131,55.9 v136.44,55.9 | v68.3,53.8 70.5,56 v76.01,56 76.01,56.07 76.71,56.77 76.71,58.04 75.95,58.8 74.8,58.8 74.04,59.56 74.04,63.75 74.55,64.26 81.42,64.26 83,62.68 | 67.8,53.8 v68.3,53.8 | v59.9,46.1 67.6,53.8 v68.3,53.8 | 37.23,32.62 34.9,30.3 34.9,30.1 | 37.23,32.62 43.8,39.2 | 43.8,39.2 v43.8,42.6 41.33,40.13 40.39,40.13 | v54.9,20.3 54.9,13.5 50.04,8.64 46.66,8.64 v42.97,4.95 43.73,4.19 61.21,4.19 61.77,3.64 v63.71,3.64 66.25,3.64 68.71,6.1 v75.69,6.1 76.58,5.21 84.33,5.21 91.19,12.06 v91.19,14.48 | v44.23,13.08 46.23,13.08 47.24,12.06 47.24,11.3 43.18,7.24 42.93,7.24 | 42.93,7.24 21.21,7.24 v21.08,7.37 21.08,16.26 v21.34,16.51 | v42.8,7.75 42.8,7.37 42.93,7.24 | v21.34,16.51 25.02,16.51 | 25.02,16.51 25.91,16.51 v27.69,18.29 28.07,18.67 v31.24,18.67 v32.64,17.27 | v29.59,12.45 26.92,12.45 25.02,14.35 25.02,16.51 | 34.9,30.1 34.9,29.31 33.91,28.32 13.97,28.32 11.43,25.78 11.43,19.56 14.22,16.76 21.08,16.76 v21.34,16.51 | v36.58,40.13 40.39,40.13 | v40.39,39.12 40.39,40.13 | 43.8,39.2 43.81,39.19 43.81,26.16 44.83,25.15 46.48,25.15 47.59,26.25 v47.59,35.37 53.03,35.37 v55.5,32.89 | J2.6 29.43,31.4 30.35,30.48 33.02,30.48 v33.15,30.61 33.27,30.61 33.66,30.23 34.77,30.23 34.9,30.1 | v37.72,32 37.72,32.13 37.23,32.62 | v120.65,4.57 120.65,2.92 119.63,1.91 99.95,1.91 99.19,2.67 99.16,2.67 98.65,3.17 98.65,4.73 v98.55,4.83 98.55,9.14 95.63,12.06 v95.63,14.48 | v63.82,64.05 65.49,64.05 68.45,61.09 68.45,57.91 | 68.45,57.91 68.45,53.95 v68.3,53.8 | v55.88,68.33 55.88,66.8 64.9,57.78 68.33,57.78 68.45,57.91 | v31.91,68.52 34.73,68.52 37.72,65.53 37.72,63.02 v37.68,62.98
  Bottom 0.406: v83,54.7 83,62.68 | 83,62.68 84.58,64.39 88.67,64.39 | 88.67,64.39 v88.9,64.15 | 88.67,64.39 89.66,64.39 | 89.66,64.39 90.17,62.87 90.17,56.33 v90.5,56 | 95.25,63.88 95.25,56.25 v95.6,55.9 | 89.66,64.39 94.74,64.39 95.25,63.88 | 95.25,63.88 97.16,63.88 97.66,64.39 101.09,64.39 102.12,63.36 | 102.12,63.36 102.16,63.32 | 102.16,63.32 102.23,63.25 107.85,63.25 v108.4,63.8 | v101.47,61.44 101.45,61.42 101.47,61.42 101.47,62.64 | v108.4,63.8 108.4,59.38 105.16,56.13 103.13,56.13 v103,56 | v110.1,55.6 110.1,58.06 108.6,59.56 108.6,63.6 v108.4,63.8 | 101.47,62.64 101.47,62.71 102.12,63.36 | 101.47,62.64 102.16,63.32 | 102.16,63.32 108.51,63.32 108.48,63.42 108.15,63.42 109.07,64.34 113.13,64.34 114.63,62.84 114.63,57.8 116.53,55.9 v119.5,55.9
  Bottom 0.61: v60.76,70.1 60.76,76.05 | 60.76,76.05 60.76,79.96 60.89,80.09 | 60.89,80.09 v62.7,82.15 | v77.81,76.04 60.77,76.04 60.76,76.05 | v41.91,84.63 45.57,84.63 50.11,80.09 60.89,80.09 | v82.96,52.53 82.96,54.66 v83,54.7
  Bottom 2.54: 137.79,41.15 138.05,40.89 | 138.05,36.5 POW.2 138.1,36.4 | 140.97,33.53 140.97,28.62 J10.2
  Bottom 3.81: POW.3 137.79,41.15 | 138.05,40.89 138.05,36.5 | 138.1,36.4 140.97,33.53
  other vias: 140.84,33.36 4.32,47.84 6.86,47.84 5.59,47.84 5.59,49.11 5.59,46.57 5.59,68.8 5.59,67.53 6.86,67.53 4.32,67.53 5.59,66.26 142.12,81.5 142.12,82.77 142.12,84.04 140.84,82.77 143.38,82.77
  pour Bottom (isolate 0.406): 0.13,94.87 145.92,94.87 145.92,0.13 0.13,0.13
  pour Top (isolate 0.406): 0.13,94.87 145.92,94.87 145.92,0.13 0.13,0.13
HWB  (via drill 0.36 pad 0.71)
  Top 0.254: R4.1 121.03,79.56 116.31,74.84 v41.54,74.84 | U1.33 33.26,60.46 v32.3,59.5
  Bottom 0.254: v32.3,59.5 26.4,59.5 23.2,62.7 23.2,69.2 28.4,74.4 41.1,74.4 v41.54,74.84
IO8  (via drill 0.36 pad 0.71)
  Top 0.254: U1.28 29.96,62.96 29.3,62.3 v29.3,56 | R40.2 v58.22,10.9 | R14.2 57.47,36.2 v56.5,36.2
  Bottom 0.254: 55.95,35.88 45.63,46.2 42.5,46.2 32.1,56.6 29.9,56.6 v29.3,56 29.5,56.2 | 55.95,35.88 58.22,33.61 v58.22,10.9 | v56.5,36.2 56.4,36.2 55.95,35.88
IO9*  (via drill 0.36 pad 0.71)
  Top 0.254: R37.1 124,80.09 117.01,73.1 v43.34,73.1 | U1.29 30.66,62.46 v30.2,62
  Bottom 0.254: v43.34,73.1 28.9,73.1 24.5,68.7 24.5,63.4 25.9,62 v30.2,62
IO10*  (via drill 0.36 pad 0.71)
  Top 0.254: R17.2 57.65,29.9 | U1.30 31.36,61.96 30.2,60.8 v30.2,53.4 | v57.5,31.3 57.45,31.25 R17.2 | R42.2 | R42.2 R17.2
  Bottom 0.254: v30.2,53.4 30.2,49.64 34.63,45.21 45.75,45.21 57.5,33.45 v57.5,31.3
IO11*  (via drill 0.36 pad 0.71)
  Top 0.254: U1.12 40.19,66.29 40.2,66.3 40.6,66.3 41.92,67.62 49.58,67.62 52.91,64.29 52.91,46.03 40.34,33.2 v39.4,33.2
  Top 0.305: R43.2 35.87,11.1 v36.05,11.3
  Bottom 0.254: v39.4,33.2 43,29.6 43,12.7 41.4,11.1 36.38,11.1 v36.05,11.3
IO12*  (via drill 0.36 pad 0.71)
  Top 0.254: U1.26 29.06,63.96 27.4,62.3 27.4,55.8 27,55.4 v27,51.01 | R44.2 52.58,35.58 R18.2 51.23,37.15 v51.48,37.41
  Bottom 0.254: v27,51.01 27.64,50.4 34.03,44.01 44.88,44.01 v51.48,37.41
IO13*  (via drill 0.36 pad 0.71)
  Top 0.254: R8.1 122.35,79.61 116.69,73.95 v42.41,73.95 | U1.32 32.66,60.96 v32.3,60.6
  Bottom 0.254: v32.3,60.6 26.4,60.6 23.9,63.1 23.9,69 28.7,73.8 42.27,73.8 v42.41,73.95
MFP
  Top 0.406: U2.7 72.56,82.44 R20.1
MISO
  Top 0.254: U1.11 41,65.5 41,65.7 42.27,66.97 49.28,66.97 52.23,64.02 52.23,46.28 50.33,44.37 40.61,34.4 J2.1
MOSI
  Top 0.254: U1.10 41.66,64.96 43,66.3 48.85,66.3 51.56,63.59 51.56,46.58 41.16,35.8 33.6,35.8 33.2,35.4 33.2,32.8 32.26,31.86 J2.4
N$1
  Top 0.254: 85.35,58.4 87,58.4 87.3,58.1 87.3,56.1 86.7,55.5 85.2,55.5 84.9,55.2 84.9,54.35 R19.2
  Top 0.305: 85.35,58.4 U8.16
N$2
  Top 0.254: RX.A R7.2
N$3
  Top 0.254: ON.A 126.17,87.22 R5.2
N$4
  Top 0.254: TX.A R6.2
N$5
  Top 0.254: U9.16 72.41,58.41 72.15,58.15 72.15,54.85 72.77,54.23 R12.2
N$6
  Top 0.61: J1.3 24.45,83.26 JP9.2
N$7
  Top 0.254: L.A 121.93,88.27 122.35,87.85 R8.2
N$11  (via drill 0.36 pad 0.71)
  Top 0.305: Q5.3 86.44,35.26 v88.7,33
  Top 0.406: 90.39,33 D8.A
  Top 1.27: v88.7,33 90.39,33
  Bottom 1.27: K3.1 86.63,30.93 v88.7,33
N$14
  Top 0.406: Q5.1 R14.1
N$15
  Top 0.61: U2.2 83.44,82.44 84.4,83.4 85.4,83.4 Y2.P$4 C27.1
N$16  (via drill 0.36 pad 0.71)
  Top 0.305: Q4.3 65.96,39.94 69.2,36.7 94.3,36.7 97.9,33.1 100.5,33.1 v100.6,33.2
  Top 1.27: v100.6,33.2 101.54,33.2 D9.A
  Bottom 1.27: K2.1 103.73,30.07 v100.6,33.2
N$17
  Top 0.61: C26.1 Y2.P$1 84.44,81.17 U2.1
N$18
  Top 0.406: Q4.1 59.36,40.89 R15.1
N$19  (2 unrouted)
  Top 3.81: POW.1 130.05,38.5 130.05,45.34 132.01,47.3 PC4.+ 135.9,49.79 138.81,52.7 140.72,52.7 142.24,54.23 143.35,55.63 D5.A
  Bottom 2.54: 140.34,23.62 140.93,23.62 J10.1
  Bottom 3.81: POW.1 132.1,34.78 137.03,29.84 137.03,25.53 138.94,23.62 140.34,23.62
N$20  (via drill 0.36 pad 0.71)
  Top 0.305: Q3.3 v63,41.7 | 120.83,29.24 118.42,31.65 65.65,31.65 v64.4,32.9
  Top 1.27: K1.1 120.83,29.24 D10.A
  Bottom 0.305: v64.4,32.9 64.4,40.3 v63,41.7
N$21
  Top 0.406: D3.K 82.08,90.28 R21.2
N$22
  Top 0.406: Q3.1 R16.1
N$23
  Top 0.406: J1.4 21.85,85.75 JP9.1
N$24  (via drill 0.36 pad 0.71)
  Top 0.305: Q6.3 69.3,29 69.6,28.7 69.6,26.66 K4.1
  Top 0.406: 73.44,33.1 D11.A
  Top 1.27: v71.6,33.1 73.44,33.1
  Bottom 0.406: 69.6,27.1 69.53,27.03 K4.1
  Bottom 1.27: v71.6,33.1 69.6,31.1 69.6,27.1
N$25
  Top 0.254: L1.A R37.2
N$26
  Top 0.406: R17.1 60.72,29.87 Q6.1
N$27
  Top 0.254: R29.1 40.76,45.94 41,45.7 41.6,45.7 U10.6
N$28
  Top 0.406: Q7.3 39.92,28.74 K5.1
  Top 0.813: 39.9,26.57 K5.1
  Top 1.27: D12.A 49.04,25.74 47.1,23.8 41.23,23.8 39.9,25.14 39.9,26.57
N$29
  Top 0.305: J5.1 106.15,15.97 105.25,16.86 68.04,16.86 65.37,14.2 R38.1
N$30
  Top 0.254: R18.1 49,35.6 47.9,34.5 47.9,33.67 Q7.1
N$31
  Top 0.305: J5.3 101.15,9.87 99.19,11.83 65.67,11.83 64.69,12.8 R39.1
N$32
  Top 0.305: J6.1 84.05,8.85 82.22,10.68 64.87,10.68 64.65,10.9 R40.1
N$33
  Top 0.305: J6.3 79.05,7.09 76.54,9.6 R41.1
N$34  (via drill 0.36 pad 0.71)
  Top 0.305: R42.1 v57.45,25.35 | v50.5,7.8 50.5,2.15 J7.1
  Bottom 0.305: v57.45,25.35 57.45,14.75 v50.5,7.8
N$35
  Top 0.254: J7.3 45.45,7.15 43.1,9.5 R43.1
N$36  (via drill 0.36 pad 0.71)
  Top 0.254: J8.1 28.35,6.15 v28.4,6.45 | R44.1 54.62,35.18 v54.62,31.24
  Bottom 0.254: v28.4,6.45 43.47,6.45 48.2,11.18 48.2,16.1 54.62,22.52 v54.62,31.24
N$37
  Top 0.254: J8.3 23.35,10.55 R45.1
N$38
  Top 0.305: J9.1 128.25,12.16 121.78,18.64 67.25,18.64 66.01,17.4 R46.1
N$39
  Top 0.305: J9.3 123.25,5.55 117.07,11.73 112.47,11.73 106.04,18.04 67.49,18.04 65.55,16.1 R47.1
N$40
  Top 0.406: J1.1 18.2,85.8 18.9,85.1 18.9,81.1 19.4,80.6 R31.1
N$41
  Top 0.305: R32.1 19.44,18.56 U3.1 18.5,18.6 18,18.1 18,14.5 18.4,14.1 U12.1
N$42
  Top 0.305: U3.3 13.8,20.5 13.04,19.74 J4.2 7.54,19.74 6.9,19.1 6.9,16.1 8.9,14.1 U12.4
N$43
  Top 0.305: J4.1 14.86,22.24 15.3,21.8 15.3,19.1 14.8,18.6 U3.4
N$44
  Top 0.305: J4.3 12.06,17.24 12.66,16.64 U12.3
N$45
  Top 1.27: 138.18,78.36 137.54,78.36 R51.1
  Top 3.81: D5.C 137.05,74.95 138.18,76.33 138.18,78.36
NC_POW  (via drill 0.36 pad 0.71)
  Top 0.254: 43,45.7 U10.4 45.34,45.8 v48.43,48.89 | v56.5,48.89 57.7,48 R16.2
  Bottom 0.254: v56.5,48.89 v48.43,48.89
OP1
  Top 1.27: J9.2 125.75,6.75 120.83,11.67 K1.S
OP2
  Top 1.27: J5.2 103.65,14.32 K2.S
OP3  (via drill 0.36 pad 0.71)
  Top 1.27: J6.2 81.55,5.95 v82.35,6.75
  Bottom 0.813: 86.7,14.33 K3.S
  Bottom 1.27: 86.7,14.33 86.7,11.1 v82.35,6.75
OP4  (via drill 0.36 pad 0.71)
  Top 0.813: 48,2.15 J7.2
  Top 1.27: v48,5.61 48,2.15
  Bottom 1.27: K4.S 69.53,10.21 64.93,5.61 v48,5.61
OP5
  Top 1.27: J8.2 25.85,7.7 27.25,9.1 31.33,9.1 32.15,9.93 32.15,11.65 33.03,12.53 36.14,12.53 38.07,12.52 K5.S
POW1  (via drill 0.36 pad 0.71)
  Top 0.406: U4.18 134.34,59.7 136.7,59.7 136.9,59.9 136.9,60.3 136.88,60.32 | 136.9,62.9 136.8,63 136.66,62.86 | 136.88,62.22 136.9,62.2 136.9,61.6 136.89,61.59 | 136.85,60.95 136.9,60.9
  Top 1.016: U4.24 136.31,63.49 v136.53,63.4 | v136.53,63.4 136.8,63 | 136.9,62.9 136.9,62.8 | v136.53,62.5 136.9,62.2 | U4.23 136.66,62.86 | U4.22 136.88,62.22 | U4.21 135.4,61.59 | 135.4,61.59 136.89,61.59 | U4.20 136.85,60.95 v136.5,60.6 136.78,60.32 | U4.19 136.78,60.32 | 136.9,61.6 v136.53,62.5 | 136.9,62.8 136.3,63.4 | 136.3,63.4 134.4,63.4 134.3,63.5 | v136.5,61.6 135.41,61.6 135.4,61.59 | 136.3,63.4 v136.53,63.4 | 136.9,62.8 v136.53,62.5 | 136.88,60.32 136.78,60.32 | 136.9,60.3 136.9,62.8
  Bottom 1.016: v136.5,61.6 136.8,61.6
  Bottom 1.778: K1.P 126.8,47.5 133.4,54.1 137.85,54.1 139.1,55.35 139.1,59.3 136.8,61.6
POW2  (via drill 0.36 pad 0.71)
  Top 0.254: 112.2,63.5 112.3,63.4 v112.34,63.4 | 112.64,62.86 112.34,62.55 v112.34,62.5 | 112.89,61.59 112.88,61.6 v112.34,61.6 | 112.75,60.95 112.5,60.7 v112.34,60.7
  Top 0.406: 112.9,62.8 112.9,62.6 112.64,62.86 | U5.24 | 112.78,62.22 112.9,62.1 | 112.89,61.59 112.9,61.6 | 112.75,60.95 112.9,61.1 | 112.78,60.32 112.9,60.2 112.9,59.9 112.68,59.68 U5.18
  Top 1.016: 112.9,60.2 112.9,61.1 112.9,61.6 112.9,62.1 112.9,62.6 | U5.24 112.2,63.5 arc-90 112.9,62.8 | U5.23 112.64,62.86 | U5.22 112.78,62.22 | U5.21 112.89,61.59 | U5.20 112.75,60.95 | U5.19 112.78,60.32
  Bottom 0.813: 113.2,62.54 v112.34,63.4
  Bottom 1.778: K2.P 109.7,31.2 103.8,37.1 103.8,47.03 111.83,55.03 111.83,58.01 112.85,59.03 112.85,61.99 v112.34,62.5
POW3  (via drill 0.36 pad 0.71)
  Top 0.254: 99.85,62.55 99.8,62.6 v99.68,62.5 | 99.85,62.22 99.6,61.97 v99.65,61.65 | 100.1,60.95 100.05,60.9 v99.62,60.72 | 100.1,60 arc-90 99.78,59.68 U6.18
  Top 0.406: U6.21 97.55,61.6 | U6.22 99.85,62.22 99.85,62.55 | U6.18 100.1,59.68 | 99.55,62.86 99.55,62.85
  Top 1.016: 98.91,63.49 U6.24 | 97.55,61.6 100.1,61.6 | U6.20 100.1,60.95 | U6.19 100.1,60.32 100.1,60.9 | U6.23 99.55,62.86 99.85,62.56 99.85,62.55 | 99.8,63.5 v99.65,63.48 U6.24 | U6.24 U6.23 | U6.21 U6.23 | 100.1,60.9 100.1,63.49 U6.24 | 100.05,60.9 arc-90 100.1,60.85 100.1,60 arc-90 99.6,60.5 v99.62,60.72 100.1,60.9
  Bottom 1.016: 99.85,62.75 v99.65,63.48
  Bottom 1.778: K3.P 92.6,47.5 99.85,54.75 99.85,62.75
POW4  (via drill 0.36 pad 0.71)
  Top 0.254: 86.99,63.49 87.2,63.28 v87.34,63.28 | 87.54,62.86 87.34,62.66 v87.34,62.48 | 87.61,61.59 87.52,61.68 v87.34,61.68 | 87.75,60.95 87.58,60.78 v87.34,60.78
  Top 0.406: 87.8,62.7 87.8,62.6 arc90 87.54,62.86 | 86.99,63.49 87,63.5 | 87.72,62.22 87.8,62.3 | 87.61,61.59 87.8,61.4 | 87.75,60.95 87.8,61 | 87.78,60.32 87.8,60.3 87.8,59.82 87.84,59.78 | U8.18 87.78,59.68 88.3,60.2 88.3,63 87.5,63.8 87.11,63.8 86.8,63.49
  Top 1.016: 87.8,60.3 87.8,61 87.8,61.4 87.8,62.3 87.8,62.6 | 87.8,62.7 87,63.5 | U8.24 86.8,63.49 86.99,63.49 | U8.23 87.54,62.86 | U8.22 87.72,62.22 | U8.21 87.61,61.59 | U8.20 87.75,60.95 | U8.19 87.78,60.32
  Bottom 1.27: 88.43,62.32 v87.34,63.28
  Bottom 1.778: K4.P 75.5,34.1 88.43,47.03 88.43,62.32
POW5  (via drill 0.36 pad 0.71)
  Top 0.254: 75.84,62.86 75.7,63 v75.7,63.1 | 75.78,62.22 v75.7,62.3 | 75.71,61.59 75.7,61.58 v75.7,61.5 | 75.72,60.95 75.7,60.8 v75.7,60.7
  Top 0.406: 75.65,62.8 75.84,62.86 | U9.24 | 75.78,62.22 75.65,62.1 | 75.71,61.59 75.65,61.4 | 75.72,60.95 75.77,60.9 | 75.82,60.32 75.77,60.27 | U9.18 75.43,59.68 75.95,60.2 75.69,60.44
  Top 1.016: 75.77,60.27 75.77,60.9 75.65,61.4 75.65,62.1 75.65,62.8 | U9.24 75.2,63.5 75.84,62.86 U9.23 | U9.22 75.78,62.22 | U9.21 75.71,61.59 | U9.20 75.72,60.95 | U9.19 75.82,60.32
  Top 1.27: 75.69,60.44 v75.7,63.1
  Top 1.778: v49.34,37.58 55.01,43.25 v59.7,43.25
  Bottom 1.27: 78.38,62.45 v75.7,63.1
  Bottom 1.778: v59.7,43.25 64.65,48.21 73.23,48.21 77.34,52.32 77.28,52.32 78.38,53.42 78.38,62.45 | K5.P 45.89,36.01 47.46,37.58 v49.34,37.58
RD_N  (via drill 0.36 pad 0.71)
  Top 0.254: U1.3 41.74,61.46 42.9,60.3 v43.2,60.3 | RN1.2 v24.7,59.5
  Bottom 0.254: v43.2,60.3 41.4,58.5 25.7,58.5 v24.7,59.5
RD_P  (via drill 0.36 pad 0.71)
  Top 0.254: U1.4 41.98,61.96 42.84,61.1 43.6,61.1 44.3,60.4 v44.3,59.6 | RN1.1 24.07,57.9 v24.3,57.9
  Bottom 0.254: v24.3,57.9 42.6,57.9 v44.3,59.6
RESET
  Top 0.254: U1.13 39.69,66.69 41.16,68.17 49.93,68.17 53.58,64.51 53.58,45.8 34.96,26.8 31.9,26.8 | 31.9,26.8 28.6,26.8 27.9,27.5 27.9,32.87 J2.5 | R1.2 31.74,26.96 31.9,26.8
  Top 0.406: D2.A J2.5
RXLED/SS  (via drill 0.36 pad 0.71)
  Top 0.254: U1.8 42.46,63.96 42.9,64.4 v48.1,64.4 | v48.1,71.41 118.66,71.41 130.56,83.31 130.56,86.25 R7.1
  Bottom 0.254: v48.1,64.4 v48.1,71.41
SCK
  Top 0.254: U1.9 42.16,64.46 43.35,65.65 48.5,65.65 50.89,63.27 50.89,46.78 40.89,36.4 33,36.4 31.97,35.37 J2.3
SCL_3  (via drill 0.36 pad 0.71)
  Top 0.254: 129.3,57.8 U4.10 130.57,57.78 131.49,58.7 131.49,64.22 130.68,65.02 130.68,65.73 v130.73,65.73 | v66.7,57 66.7,57.2 67.28,57.78 U9.10 70,57.78 70.9,58.68 70.9,65.1 v71.1,65.3 | 32.7,77.8 32.8,77.8 | v36.5,21.2 36.9,21.2 37.8,22.1 37.8,28.13 54.79,45.25 54.79,51.79 57.4,54.4 v58,54.4 | U8.10 82.28,57.78 82.8,58.3 82.8,65.3 v83.1,65.73 | U5.10 106.78,57.78 107.5,58.5 107.5,65.4 v107.83,65.73 | 116.63,57.8 118.2,57.8 118.8,58.4 118.8,65.1 v119.3,65.73 | U6.10 94.68,57.78 95.1,58.2 95.1,65.5 v95.2,65.73
  Top 0.305: 116.63,57.8 U7.10 | v25.1,18.2 U16.8
  Top 0.406: U11.6 28.24,76.04 30.3,78.1 32.4,78.1 32.7,77.8 | R22.2 34.29,79.45 | 34.29,79.45 Q1.2 | v32.8,76.9 32.8,77.8 33.9,78.9 34.29,79.45
  Bottom 0.254: 64.8,57 65,57 | 65,57 v66.7,57 | 65,57 64.6,57.02 40.86,80.76 36.99,80.76 35.4,79.3 35.4,77.5 34.8,76.9 v32.8,76.9 | v71.1,65.3 71.4,65.73 v83.1,65.73 v95.2,65.73 v107.83,65.73 v119.3,65.73 v130.73,65.73
  Bottom 0.305: 64.6,57.02 61.97,54.4 v58,54.4 | v25.1,18.2 26.7,19.8 35.1,19.8 v36.5,21.2
SDA_3  (via drill 0.36 pad 0.71)
  Top 0.254: R26.2 30.83,79.38 Q2.2 30.65,81.25 30.8,81.4 30.8,82.94 31.19,83.33 36.82,83.33 v37.38,83.4 | 68.68,58.4 U9.9 69.89,58.41 70.3,58.83 70.3,66.33 v70.5,66.53 | U4.9 129.33,58.4 130.52,58.4 130.92,58.8 130.92,64.03 129.92,65.02 129.92,65.91 129.92,66.17 v129.9,66.53 | 80.37,58.4 82,58.4 82.2,58.6 v82.2,66.53 | v34.5,22.1 35.9,22.1 37.2,23.4 37.2,28.32 54.2,45.57 54.2,57.7 v62.7,66.2 | U5.9 106.61,58.41 106.9,58.7 v106.9,66.53 | U7.9 118.01,58.41 118.3,58.7 118.3,66.2 v118.37,66.53 | U6.9 94.11,58.41 94.4,58.7 v94.4,66.53
  Top 0.305: U8.9 80.37,58.4 | v25.1,21.8 v25.09,21.79 U16.7
  Top 0.406: U11.1 29.54,78.84 29.9,79.2 Q2.2
  Bottom 0.254: v37.38,83.4 45.5,83.4 | v129.9,66.53 v118.37,66.53 v106.9,66.53 v94.4,66.53 v82.2,66.53 v70.5,66.53
  Bottom 0.305: v34.5,22.1 25.4,22.1 v25.1,21.8 | 45.5,83.4 v62.7,66.2 70.3,66.2 v70.5,66.53
THM0
  Top 0.254: R13.P$9 32.71,22.16 U16.1
  Top 0.305: J5.5 96.15,8.25 93.15,11.25 65.29,11.25 64.65,11.9 55.8,11.9 55.44,11.66 48.35,11.66 39.65,20.36 U16.1
THM1
  Top 0.254: U16.13 31.44,17.4 32.1,18.06 32.1,22.6 33.04,23.54 R13.P$8
  Top 0.305: J6.5 74.05,5.85 71.3,8.6 45.84,8.6 41.9,12.53 41.9,15.76 40.77,16.89 38.99,16.89 37.85,15.75 37.85,14.55 36.95,13.65 31.9,13.65 31.44,14.11 U16.13 31.4,15.6
THM2  (via drill 0.36 pad 0.71)
  Top 0.254: R13.P$7 30.5,23.3 30.17,22.97 U16.3 30.17,17.93 30.8,17.3 v30.8,10.5 | J7.5 40.45,8.45 v40.4,8.5
  Bottom 0.254: v40.4,8.5 32.1,8.5 30.8,9.8 v30.8,10.5
THM3
  Top 0.203: J8.5 18.35,10.05 19.7,11.4 26.2,11.4 28.9,14.1 U16.11
  Top 0.254: U16.11 28.9,18.4 29.54,19.04 29.54,22.06 27.96,23.64 R13.P$6
TXLED  (via drill 0.36 pad 0.71)
  Top 0.254: U1.22 30.57,66.23 29.7,67.1 v29.7,68.15 | v44.2,72.08 118.2,72.21 118.2,72.23 128.27,82.3 128.27,86.36 R6.1
  Bottom 0.254: v29.7,68.15 29.7,70.95 30.45,71.83 43.95,71.83 44.15,72.01 44.13,71.88 v44.2,72.08
UCAP
  Top 0.254: U1.6 42.61,62.96 42.97,62.6 43.34,62.6 C5.1
VBAT
  Top 0.406: R21.1 C25.1 80.1,87.6 80.1,83.9 80.3,83.7 U2.3
VIN_5
  Top 0.305: U9.7 67.22,59.68 66.4,60.5 66.4,61.5 66.9,61 | U9.6 67.38,60.32 66.44,60.62 66.9,60.8 | 66.9,60.9 66.9,61 | 66.9,61 66.9,61.6 67.5,62.2
  Top 0.406: U9.3 68.65,62.2 | U8.7 79.02,59.68 78.38,60.32 | 79.12,68.05 77.42,68.99 | U8.4 78.19,61.59 78.1,61.5 | 78.12,62.22 78.1,62.2 | U8.2 78.16,62.86 78.1,62.8 | 79.12,62.87 78.11,63.49 78.11,68.19 78.1,68.2 | U6.7 91.22,59.68 90.65,60.25 90.72,60.32 | 91.32,67.87 89.82,68.99 | 90.45,60.95 90.3,61.1 | 90.31,61.59 90.3,61.6 | 90.48,62.22 90.3,62.4 | 90.36,62.86 90.3,62.8 | 90.41,63.49 91.32,63.47 | U5.7 103.92,59.68 103.4,60.2 | 103.4,60.2 103.2,60.4 | 104.09,68 102.97,68.99 | 103.52,60.32 103.4,60.2 | 103.25,60.95 103.2,60.9 | 103.21,61.59 103.2,61.6 | 103.28,62.22 103.2,62.3 | 103.26,62.86 103.2,62.8 | 103.21,63.49 104.09,63.5 | U7.7 115.22,59.68 114.8,60.1 114.93,60.3 114.94,60.32 | 115.82,67.7 114.53,68.99 | U7.5 114.85,60.95 114.93,61 | 114.81,61.59 114.93,61.6 | 114.88,62.22 114.93,62.3 | 114.84,62.86 114.93,62.9 | 114.89,63.49 115.82,63.4 | U4.7 127.92,59.68 127.4,60.2 | 127.4,60.2 127.2,60.4 | 127.58,69.02 127.17,68.99 | 127.52,60.32 127.4,60.2 | 127.25,60.95 126.69,60.9 | 127.21,61.59 126.69,62.62 | 127.22,62.22 127.07,63.22 | 127.34,62.86 127.2,63 | 127.21,63.49 127.58,62.99 | U9.7
  Top 0.61: U9.3 68.2,61.75 68.5,61.75 U9.4
  Top 1.016: 78.1,61 78.1,60.6 78.38,60.32 U8.6 | 78.1,61 78.1,61.5 78.1,62.2 78.1,62.8 79.12,62.87 | U8.5 78.15,60.95 78.1,61 | U8.3 78.12,62.22 | U8.1 78.11,63.49 | 90.65,60.25 90.3,60.6 90.3,61.1 90.3,61.6 90.3,62.4 90.3,62.8 91.32,63.47 | U6.6 90.72,60.32 | U6.5 90.45,60.95 | U6.4 90.31,61.59 | U6.3 90.48,62.22 | U6.2 90.36,62.86 | U6.1 90.41,63.49 | 103.2,60.4 103.2,60.9 103.2,61.6 103.2,62.3 103.2,62.8 104.09,63.5 | U5.6 103.52,60.32 | U5.5 103.25,60.95 | U5.4 103.21,61.59 | U5.3 103.28,62.22 | U5.2 103.26,62.86 | U5.1 103.21,63.49 | 114.93,60.3 114.93,61 114.93,61.6 114.93,62.3 114.93,62.9 115.82,63.4 | U7.6 114.94,60.32 | U7.4 114.81,61.59 | U7.3 114.88,62.22 | U7.2 114.84,62.86 | U7.1 114.89,63.49 | 127.2,60.4 126.69,60.9 126.69,62.62 127.07,63.22 127.2,63 127.58,62.99 | U4.6 127.52,60.32 | U4.5 127.25,60.95 | U4.4 127.21,61.59 | U4.3 127.22,62.22 | U4.2 127.34,62.86 | U4.1 127.21,63.49
  Top 1.27: U9.5 U9.6 | U9.2 U9.3 U9.4 U9.5 | U9.5 68.25,60.95 68.2,60.9 | 66.9,60.8 66.9,60.9 67,61 | 67,61.6 67,61 | 67,61 67.1,61 | 67,61 66.9,61 67,60.9 | 133.1,78.36 133.86,78.36 R51.2
  Top 1.676: U9.2 68.5,63.03 68.5,66.4 68.2,66.1 68.2,63.1 68.59,63.49 U9.1
  Top 2.032: 127.96,72.93 127.17,68.99 | 66.44,60.62 66.44,65.38 67.1,65.4 67.35,66.68
  Top 2.54: 67.75,63.74 67.8,60.9 68.2,60.9
  Top 3.048: 79.12,62.87 79.12,68.05 | 91.32,63.47 91.32,67.87 | 104.09,63.5 104.09,68 | 115.82,63.4 115.82,67.7 | 127.58,62.99 127.58,69.02
  Top 3.81: 67.35,66.68 69.03,68.99 77.42,68.99 89.82,68.99 102.97,68.99 114.53,68.99 127.17,68.99 127.17,69.43 PC2.+ 127.18,75.11 130.43,78.36 133.1,78.36
VUSB  (via drill 0.36 pad 0.71)
  Top 0.254: U1.7 43.03,63.46 arc90 v43.17,63.5 | C9.1 17.52,68.22 | 15.75,66.45 15.31,66.01 F1.2
  Top 0.406: R2.2 C9.1 | 16.8,67.5 16.6,67.3
  Top 0.61: 17.52,68.22 16.6,67.3 | 16.6,67.3 15.75,66.45 | v27.06,66.48 26.1,67.3 16.6,67.3
  Bottom 0.406: v27.06,66.48 33.53,66.48 35.18,64.83 35.18,63.5 36.7,61.98 38.86,61.98 40.39,63.5 v43.17,63.5
VUSBD
  Top 0.254: C14.+ F1.1 14.36,61.8 13.6,61.8 12.03,60.23 J3.1
XTAL1
  Top 0.254: U1.17 37.69,67.91 36.5,69.1 36.5,70.37 Y3.3 35.65,71.23 C13.2
XTAL2
  Top 0.254: U1.16 38.19,67.59 39.4,68.8 39.4,70.09 Y3.1 | 38.99,70.41 Y3.1 | C12.2 39.2,71.24 39.2,70.29 Y3.1
(copper drawn outside any net)
  shapes: Bottom area x12

## Text on the board
tPlace: + | + | + | + | 1 | 1 | 1 | 1 | Wagman V3.1, 02/2016 | 1 | http://wa8.gl/NodeController/nodecontroller-v3.1.html | 1 | 1